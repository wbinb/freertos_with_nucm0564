# Keil uVision project GPIO_OutputInput.uvproj, settings and files
target GPIO_OutputInput (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M0564VG4AE Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: GPIO_OutputInput
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\Device\Nuvoton\M0564\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_M0564.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M0564/Source/ARM/: startup_M0564.s
    ../../../Library/Device/Nuvoton/M0564/Source/: system_M0564.c
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c gpio.c clk.c sys.c uart.c
  group freertos
    ../../../ThirdParty/FreeRTOS/Source/: list.c tasks.c queue.c timers.c croutine.c event_groups.c stream_buffer.c
    ../../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
